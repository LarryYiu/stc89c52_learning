# Keil uVision project stc89c52.uvproj, settings and files
target stc89c52 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: stc89c52 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\DRIVER;.\APP;.\LIB
  group APP
    ./: STARTUP.A51
    ./APP/: main.c config.h
  group DRIVER
    ./DRIVER/: StepMotor.c Uart.c DigitalTube.c Servo.c
  group LIB
    ./LIB/: Utility.c Interrupt.c
